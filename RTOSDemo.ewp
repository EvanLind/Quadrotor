# IAR project RTOSDemo.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; USE_USB_OTG_FS
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: STM32\; STM32\board\; STM32\Libraries\STM32F4xx_StdPeriph_Driver\inc\; STM32\Libraries\CMSIS\ST\STM32F4xx\Include\; STM32\Libraries\CMSIS\Include\; STM32\Libraries\STM32F4xx_StdPeriph_Driver\inc\; STM32\Libraries\STM32_USB_OTG_Driver\inc\; STM32\Libraries\STM32_USB_Device_Library\Class\hid\inc\; STM32\Libraries\STM32_USB_Device_Library\Core\inc\; uCos-II\Source\; uCos-II\Ports\; USER_CODE\; uCos-II\Config\; uCos-II\uC-LIB\; uCos-II\uC-CPU\; RCSLIB\RCSBaseLib\; RCSLIB\RCSInterface\; RCSLIB\RCSMotion\; OLED\; Hardware\; Hardware\MPU6050\; Hardware\I2C\; Hardware\HMC5883L\; Hardware\Motor\; Hardware\PPM\; Hardware\Beep\; Hardware\SONAR\; Hardware\IMU\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: STM32\; STM32\board\; STM32\Libraries\STM32F4xx_StdPeriph_Driver\inc\; STM32\Libraries\CMSIS\ST\STM32F4xx\Include\; STM32\Libraries\CMSIS\Include\; STM32\Libraries\STM32F4xx_StdPeriph_Driver\inc\; STM32\Libraries\STM32_USB_OTG_Driver\inc\; STM32\Libraries\STM32_USB_Device_Library\Class\hid\inc\; STM32\Libraries\STM32_USB_Device_Library\Core\inc\; uCos-II\Source\; uCos-II\Ports\; USER_CODE\; uCos-II\uC-LIB\; uCos-II\uC-CPU\; uCos-II\Config\
  OBJCOPY.OOCOutputFile: RTOSDemo.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkKeepSymbols: iap
  ILINK.IlinkIcfFile: config\stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    STM32/: stm32f4xx_it.c
  group BSP
    STM32/: bsp.c bsp_int.c
  group BSP/board
    STM32/Libraries/CMSIS/ST/STM32F4xx/: startup_stm32f4xx.s system_stm32f4xx.c
    STM32/board/: stm32f4_discovery.c
    STM32/: stm32f4_discovery_lis302dl.c
  group BSP/STM32F4xx_StdPeriph_Driver
    STM32/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group BSP/USB/STM32_USB_Device_Library/Class/hid
    STM32/Libraries/STM32_USB_Device_Library/Class/hid/src/: usbd_hid_core.c
  group BSP/USB/STM32_USB_Device_Library/Core
    STM32/Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group BSP/USB/STM32_USB_OTG_Driver
    STM32/Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group Hardware/Beep
    Hardware/Beep/: Beep.c Beep.h
  group Hardware/HCM5883L
    Hardware/HMC5883L/: HMC5883.c HMC5883.h
  group Hardware/I2C
    Hardware/I2C/: IIC.c IIC.h MPUI2C.c MPUI2C.h
  group Hardware/IMU
    Hardware/IMU/: IMU.c IMU.h
  group Hardware/Motor
    Hardware/Motor/: Motor.c Motor.h
  group Hardware/MPU6050
    Hardware/MPU6050/: dmp_driver.c dmp_driver.h dmp_fun.h dmp_mpu6050.c dmp_mpu6050.h
  group Hardware/PPM
    Hardware/PPM/: PPM.c PPM.h
  group Hardware/SONAR
    Hardware/Sonar/: Sonar.c Sonar.h
  group OLED
    OLED/: ASCII.c oled.c
  group RCSBaseLib
    RCSLIB/RCSBaseLib/: RCS_BTDebuger.c RCS_BTDebuger.h RCS_CAN.c RCS_CAN.h RCS_CommonFunction.h RCS_Eeprom.c RCS_Eeprom.h RCS_Exti.c RCS_Exti.h RCS_I2C.c RCS_I2C.h RCS_JoyStick.c RCS_JoyStick.h RCS_Para.c RCS_Para.h RCS_Pwm.c RCS_Pwm.h RCS_spi.c RCS_spi.h RCS_TimerInterrupt.c RCS_TimerInterrupt.h RCS_Types.c RCS_Types.h RCS_Usart.c RCS_Usart.h
  group RCSInterface
    RCSLIB/RCSInterface/: RCS_InputInterface.c RCS_InputInterface.h RCS_UARTCCD.c RCS_UARTCCD.h
  group RCSMotion
    RCSLIB/RCSMotion/: RCS_Motion_Basemove.c RCS_Motion_Basemove.h RCS_Motion_Encoder.c RCS_Motion_Encoder.h
  group uCOS-II/uCOS-II_CPU
    uCOS-II/uC-CPU/: cpu_a.asm cpu_c.c cpu_core.c
  group uCOS-II/uCOS-II_Lib
    uCOS-II/uC-LIB/: lib_ascii.c lib_mem.c lib_mem_a.asm lib_str.c
  group uCOS-II/uCOS-II_Source
    uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS-II/uCOS_Config
    uCOS-II/Config/: app_cfg.h cpu_cfg.h os_cfg.h
  group uCOS-II/uCOS_II_Ports
    uCOS-II/Ports/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group User_Code
    USER_CODE/: _main.c rcs.h
